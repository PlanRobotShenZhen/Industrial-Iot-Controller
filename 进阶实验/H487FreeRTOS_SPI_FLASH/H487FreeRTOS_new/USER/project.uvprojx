# Keil uVision project project.uvprojx, settings and files
target N32H487 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32H487VE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\DriverLayer\inc;..\HARDWARE\inc;..\Utils\inc;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group USER
    ./: main.c n32h47x_48x_it.c system_n32h47x_48x.c userdef.h
    ../FREERTOS/include/: FreeRTOSConfig.h
  group CORE
    ../CORE/: startup_n32h487.s
  group FWLIB
    ../FWLIB/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group FREERTOS\Source
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FREERTOS\Source\portable
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FREERTOS/portable/MemMang/: heap_4.c
  group DriverLayer
    ../DriverLayer/src/: adc.c led.c usart.c init.c
    ./: spi.c
  group Utils
    ../Utils/src/: CRC.c
